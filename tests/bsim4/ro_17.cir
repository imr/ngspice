*****************==== 17-Stage CMOS RO ====*******************
***********Benchmarking Implementation of BSIM4.6.1 by Mohan V. Dunga 12/13/2006.
.include modelcard.nmos
.include modelcard.pmos

vdd 1 0 2.0
mp1 3 2 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u
+ geomod=2 min=0 nf=2 rgeomod=3 SA=2u SB=8u NF=3 SD=0.2u
mn1 3 2 0 0 n1 l=0.18u w=5u
+ geomod=2 min=0 nf=1 rgeomod=8 SA=2u SB=8u NF=3 SD=0.2u
mp2 4 3 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u SA=2u SB=8u NF=3 SD=0.2u
mn2 4 3 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u SA=2u SB=8u NF=3 SD=0.2u
mp3 5 4 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u SA=2u SB=8u NF=3 SD=0.2u
mn3 5 4 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mp4 6 5 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mn4 6 5 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mp5 7 6 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mn5 7 6 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mp6 8 7 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mn6 8 7 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mp7 9 8 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mn7 9 8 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mp8 10 9 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mn8 10 9 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mp9 11 10 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mn9 11 10 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mp10 12 11 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u SA=2u SB=8u NF=3 SD=0.2u
mn10 12 11 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u

mp11 13 12 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u SA=2u SB=8u NF=3 SD=0.2u
mn11 13 12 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mp12 14 13 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u SA=2u SB=8u NF=3 SD=0.2u
mn12 14 13 0 0 n1 l=0.18u w=5u ad=5p SA=2u SB=8u NF=3 SD=0.2u
mp13 15 14 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mn13 15 14 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mp14 16 15 1 1 p1 l=0.18u w=10u ad=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mn14 16 15 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mp15 17 16 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mn15 17 16 0 0 n1 l=0.18u w=5u ad=5p as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mp16 18 17 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u  SA=2u SB=8u NF=3 SD=0.2u
mn16 18 17 0 0 n1 l=0.18u w=5u pd=6u as=5p ps=6u SA=2u SB=8u NF=3 SD=0.2u
mp17 2  18 1 1 p1 l=0.18u w=10u ad=5p pd=6u as=5p ps=6u SA=2u SB=8u NF=3 SD=0.2u
mn17 2  18 0 0 n1 l=0.18u w=5u ad=5p pd=6u as=5p ps=6u SA=2u SB=8u NF=3 SD=0.2u
c1 18 0 .1p

*.ic v(2)=2.0 v(3)=0 v(4)=2.0
.ic v(2)=2.0 v(3)=0.0 v(4)=2.0 v(5)=0.0 v(6)=2.0
.ic v(7)=0.0 v(8)=2.0 v(9)=0.0 v(10)=2.0 v(11)=0.0 v(12)=2.0
.ic v(13)=0.0 v(14)=2.0 v(15)=0.0 v(16)=2.0 v(17)=0.0 v(18)=2.0
*.ic V(10)=5 v(2)=5 v(3)=5 v(4)=5 v(5)=5 v(6)=5
.tran .1ns 10ns
.options reltol=1e-3 noacct
.print tran v(2)
.plot tran v(5)
.end
