* test de titré

.control
set hcopydevtype = postscript
set hcopypscolor=1
set hcopyscale=0.5
set color2=rgb:F/0/0
setcs hcopyfont=Arial
set hcopyfontsize=14
set color0="black"
set color1="white"
let x = vector(5)
let y = exp(x)
setcs xfont="Times New Roman"
set xfont_size=18
plot y vs x xlabel 'Labellisé X' ylabel 'Labellisé Y: ÜüÖöÄäÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜ' title 'Titré'
set color0="white"
set color1="black"
set xfont_size=16
setcs xfont="Arial"
plot y vs x xlabel 'Я могу есть стекло, оно мне не вредит' ylabel 'Я могу есть стекло, оно мне не вредит' title 'Я могу есть стекло, оно мне не вредит'
set color0="yellow"
set color1="red"
set xfont_size=18
setcs xfont="Noto Sans CJK JP Medium"
plot y vs x+0.001 xlabel 'Titré 私はガラスを食べられます。それは私を傷つけません' ylabel 'Titré 나는 유리를 먹을 수 있어요. 그래도 아프지 않아요' title 'Titré 我能吞下玻璃而不伤身体。' loglog

*plot y vs x+0.001 xlabel 'Labellisé X' title 'Titré' loglog

*hardcopy plot_5.ps y vs x xlabel 'Labellisé X' ylabel 'Labellisé Y' title 'Titré Äü @µ€~'
*shell Start /B plot_5.ps
echo 나는 유리를 먹을 수 있어요. 그래도 아프지 않아요
echo 私はガラスを食べられます。それは私を傷つけません
echo 我能吞下玻璃而不伤身体。

setcs sourcepath = ( "D:/Spice_general/tests/utf-8/стекло/있어요" )
source ext-utf8-2.cir

gnuplot test.gn y vs x xlabel 'Labellisé X' ylabel 'tüTÄtö Äü @µ€~' title 'ฉันกินกระจกได้ แต่มันไม่ทำให้ฉันเจ็บ '

*quit
.endc
