* test de titré
.control

* for CYGWIN
setcs xfont='Noto Sans CJK JP Medium'
set xfont_size=16
* for LINUX
*setcs xfont='Noto Sans Korean'

let x = vector(5)
let y = exp(x)
setcs wfont='Arial'
set wfont_size=18
plot y vs x xlabel 'Labellisé X' ylabel 'Labellisé Y: ÜüÖöÄäÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜ' title 'Titré 11'
plot y vs x xlabel '我能吞下玻璃而不伤身体' ylabel 'Я могу есть стекло, оно мне не вредит' title 'Titré 12 أنا قادر على أكل الزجاج و هذا لا يؤلمني.'
plot y vs x+0.001 xlabel 'Labellisé X' ylabel 'Labellisé Y' title 'Titré 13 私はガラスを食べられます。それは私を傷つけません' loglog
plot y vs x+0.001 xlabel 'Titré 私はガラスを食べられます。それは私を傷つけません' ylabel '나는 유리를 먹을 수 있어요. 그래도 아프지 않아요' title 'Titré 14 我能吞下玻璃而不伤身体。' loglog

* for CYGWIN
*setcs xfont='Adobe Times'
* for LINUX
setcs xfont='Efont Biwidth'
plot y vs x+0.001 xlabel 'Labellisé X' ylabel ' أنا قادر على أكل الزجاج و هذا لا يؤلمني.' title 'Titré 15' loglog

write D:/Spice_general/tests/utf-8/'стекло'/'있어요'/ext-utf8-1.out  x y

*setcs sourcepath = ( './utf-8/стекло/있어요' )
source $inputdir/ext-utf8-2.cir

echo 私はガラスを食べられます。それは私を傷つけません
echo 나는 유리를 먹을 수 있어요. 그래도 아프지 않아요

gnuplot test.gn y vs x xlabel 'Labellisé X' ylabel 'tüTÄtö Äü @µ€~' title 'ฉันกินกระจกได้ แต่มันไม่ทำให้ฉันเจ็บ '

*quit
.endc
