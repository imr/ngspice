* test de titré
.control
set hcopydevtype = postscript
set hcopypscolor=1
set hcopypstxcolor=21
set hcopyscale=1
if ($oscompiled = 1) or ($oscompiled = 8)
  set color2=rgb:FF/0/0
else
  set color2=rgb:F/0/0
end
setcs hcopyfont=Arial
set hcopyfontsize=18

let x = vector(5)
let y = exp(x)
setcs wfont=Arial
set wfont_size=18
setcs xfont='Noto Sans CJK JP Medium'
*set xfont_size=16

set xgridwidth=4
set xbrushwidth=1

set nolegend

*hardcopy

**plot y vs x xlabel 'Labellisé X' ylabel 'Labellisé Y: ÜüÖöÄäÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜ' title 'Titré'
plot y vs x  xlabel '我能吞下玻璃而不伤身体'    ylabel 'Я могу есть стекло, оно мне не вредит'    title 'ฉันกินกระจกได้ แต่มันไม่ทำให้ฉันเจ็บ '
* With Linux the next one requires: export LC_CTYPE ="de_DE.UTF-8"
**gnuplot test.gn y vs x   xlabel 'Labellisé X'     ylabel 'tüTÄtö Äü @µ€~'      title 'ฉันกินกระจกได้ แต่มันไม่ทำให้ฉันเจ็บ '

set xgridwidth=1
set xbrushwidth=4

**plot y vs x+0.001 xlabel 'Labellisé X' ylabel 'Labellisé Y' title 'Titré 私はガラスを食べられます。それは私を傷つけません' loglog
*plot y vs x+0.001 xlabel 'Labellisé X' title 'Titré' loglog
plot y vs x     xlabel '래도 아프지 않아요'      ylabel '私はガラスを食べられます'      title ' أنا قادر على أكل الزجاج و هذا لا يؤلمني.'

* With Linux the next one requires: export LC_CTYPE ="de_DE.UTF-8"
**gnuplot test2.gn y vs x xlabel 'Labellisé X' ylabel 'tüTÄtö Äü @µ€~' title 'ฉันกินกระจกได้ แต่มันไม่ทำให้ฉันเจ็บ '

hardcopy plot_5.ps y vs x xlabel 'Labellisé X' ylabel 'Labellisé Y' title 'Titré Äü @µ€~'
if ($oscompiled = 1) or ($oscompiled = 8)
  shell Start /B plot_5.ps
end
if ($oscompiled = 2)
  shell xterm -e gs plot_5.ps &
end
if ($oscompiled = 6)
  shell gv plot_5.ps &
end
if ($oscompiled = 7)
  shell open -a Preview plot_5.ps &
end

wrdata test.out y vs x

echo 나는 유리를 먹을 수 있어요. 그래도 아프지 않아요
echo 私はガラスを食べられます。それは私を傷つけません
echo 我能吞下玻璃而不伤身体

*quit
.endc
