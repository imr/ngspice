* test de titré 있어요
* appologize for nonsense text

.control

* for CYGWIN
setcf xfont='Noto Sans CJK JP Medium'
set xfont_size=18

let x = vector(5)
let y = exp(x)
setcf wfont='Arial'
set wfont_size=18
plot y vs x xlabel 'Labellisé X' ylabel 'Labellisé Y: ÜüÖöÄäÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜ' title 'Titré 11'
plot y vs x xlabel '我能吞下玻璃而不伤身体' ylabel 'Я могу есть стекло, оно мне не вредит' title 'Titré 12 أنا قادر على أكل الزجاج و هذا لا يؤلمني.'
plot y vs x+0.001 xlabel 'Labellisé X' ylabel 'Labellisé Y' title 'Titré 13 私はガラスを食べられます。それは私を傷つけません' loglog
plot y vs x+0.001 xlabel 'Titré 私はガラスを食べられます。それは私を傷つけません' ylabel 'Titré 14 나는 유리를 먹을 수 있어요. 그래도 아프지 않아요' title 'Titré 我能吞下玻璃而不伤身体。' loglog

* for CYGWIN
setcf xfont='Times New Roman'
plot y vs x+0.001 xlabel 'Labellisé X' ylabel ' أنا قادر على أكل الزجاج و هذا لا يؤلمني.' title 'Titré 15' loglog

setcf sourcepath = ( 'D:/Spice_general/tests/utf-8/стекло/있어요' )
source ext-utf8-4.cir

* better to put ouput into single quotes
echo 1 '私はガラスを食べられます。それは私を傷つけません'
echo 2 '나는 유리를 먹을 수 있어요. 그래도 아프지 않아요'

gnuplot test.gn y vs x xlabel 'Labellisé X' ylabel '있어요 tüTÄtö Äü @µ€~' title 'ฉันกินกระจกได้ แต่มันไม่ทำให้ฉันเจ็บ '

*quit
.endc
