* test de titré
.control
set hcopydevtype = postscript
set hcopypscolor=1
set hcopyscale=1
set color2=rgb:FF/0/0
*setcs hcopyfont=Arial
*
*setcs hcopyfont='Nimbus Mono-Regular'
* for CYGWIN
setcs hcopyfont='NimbusMonL-Bold'
*setcs hcopyfont='URWGothicL-Book'
set hcopyfontsize=14

* for CYGWIN
setcs xfont='Noto Sans CJK JP Medium'
set xfont_size=18
*setcs xfont='Noto Sans Japanese'

let x = vector(5)
let y = exp(x)
setcs wfont='Arial'
set wfont_size=18
plot y vs x xlabel 'Labellisé X' ylabel 'Labellisé Y: ÜüÖöÄäÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜ' title 'Titré 21'
plot y vs x xlabel '我能吞下玻璃而不伤身体' ylabel 'Я могу есть стекло, оно мне не вредит' title 'Titré 22 أنا قادر على أكل الزجاج و هذا لا يؤلمني.'
plot y vs x+0.001 xlabel 'Labellisé X' ylabel 'Labellisé Y' title 'Titré 23 私はガラスを食べられます。それは私を傷つけません' loglog
*LINUX
*setcs xfont='Noto Sans Korean'
plot y vs x+0.001 xlabel 'Titré 私はガラスを食べられます。それは私を傷つけません' ylabel '나는 유리를 먹을 수 있어요. 그래도 아프지 않아요' title 'Titré 24 我能吞下玻璃而不伤身体。' loglog
* for CYGWIN
setcs xfont='Times New Roman'
plot y vs x+0.001 xlabel 'Labellisé X' ylabel ' أنا قادر على أكل الزجاج و هذا لا يؤلمني.' title 'Titré 25' loglog

hardcopy plot_5.ps y vs x xlabel 'Labellisé X' ylabel 'Labellisé Y' title 'Titré Äü @µ€~'
* for MS Windows only
shell Start /B plot_5.ps
* for CYGWIN
*shell xterm -e gs  plot_5.ps &

echo  些 𣎏 世 咹 水 晶 𦓡 空 𣎏 害 咦
echo אני יכול לאכול זכוכית וזה לא מזיק לי.

*gnuplot test.gn y vs x xlabel 'Labellisé X' ylabel 'tüTÄtö Äü @µ€~' title 'ฉันกินกระจกได้ แต่มันไม่ทำให้ฉันเจ็บ '

*quit
.endc
