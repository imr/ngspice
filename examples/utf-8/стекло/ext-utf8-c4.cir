* titré 'test of various color inputs for background, text/grid and graphs 4'
* to figure out the available font names, run the command
* 'fc-list | cut -f2 -d: | sort -u | less -r > fonts-avail.txt'
.control

let x = vector(5)
let y = exp(x)

*setcs xfont='Baekmuk Dotum'
setcs  xfont='Noto Sans CJK JP'
*setcs xfont='맑은 고딕'
set xfont_size=20

set xgridwidth=1
set xbrushwidth=8
set color2=rgbd:0/126/0
set color0=blue
unset nolegend
* color1 (text/grid) selected automatically
plot y vs x xlabel '我能吞下玻璃而不伤身体' ylabel 'Я могу есть стекло, оно мне не вредит' title ' أنا قادر على أكل الزجاج و هذا لا يؤلمني.'
set color2=rgbd:0/0/255
set color1=rgb:0/0/0
set color0=white
set xbrushwidth=4
set xgridwidth=2
set nolegend
plot y vs x xlabel '나는 유리를 먹을 수 있어요' ylabel 'それは私を傷つけません' title ' أنا قادر على أكل الزجاج و هذا لا يؤلمني.'
echo 나는 유리를 먹을 수 있어요. 그래도 아프지 않아요
echo 私はガラスを食べられます。それは私を傷つけません
echo 我能吞下玻璃而不伤身体

*quit
.endc
