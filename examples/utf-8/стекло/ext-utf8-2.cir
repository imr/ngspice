* test de titré
.control
set hcopydevtype = postscript
set hcopypscolor=1
set hcopyscale=0.5
set color2=rgb:F/0/0
setcs hcopyfont=Arial
set hcopyfontsize=14

let x = vector(5)
let y = exp(x)
setcs wfont=Arial
set wfont_size=18
setcs xfont='Noto Sans Chinese'
set gridwidth=4
*set xbrushwidth=4
*set xfont_size=18
plot y vs x xlabel 'Labellisé X' ylabel 'Labellisé Y: ÜüÖöÄäÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜ' title 'Titré'
plot y vs x xlabel '我能吞下玻璃而不伤身体' ylabel 'Я могу есть стекло, оно мне не вредит' title ' أنا قادر على أكل الزجاج و هذا لا يؤلمني.'
plot y vs x+0.001 xlabel 'Labellisé X' ylabel 'Labellisé Y' title 'Titré 私はガラスを食べられます。それは私を傷つけません' loglog
*plot y vs x+0.001 xlabel 'Labellisé X' title 'Titré' loglog
plot y vs x xlabel '래도 아프지 않아요' ylabel '私はガラスを食べられます' title ' أنا قادر على أكل الزجاج و هذا لا يؤلمني.'

*hardcopy plot_5.ps y vs x xlabel 'Labellisé X' ylabel 'Labellisé Y' title 'Titré Äü @µ€~'
*shell Start /B plot_5.ps
echo 나는 유리를 먹을 수 있어요. 그래도 아프지 않아요
echo 私はガラスを食べられます。それは私を傷つけません
echo 我能吞下玻璃而不伤身体

* the next one requires: export LC_CTYPE ="de_DE.UTF-8"
gnuplot test.gn y vs x xlabel 'Labellisé X' ylabel 'tüTÄtö Äü @µ€~' title 'ฉันกินกระจกได้ แต่มันไม่ทำให้ฉันเจ็บ '

*quit
.endc
