* titré 'test of various color inputs for background, text/grid and graphs 2'
.control
set hcopydevtype = postscript
set hcopypscolor=25
set hcopypstxcolor=21
set hcopyscale=1
*set color2=rgb:F/0/0

setcs hcopyfont=Arial
set hcopyfontsize=18

let x = vector(5)
let y = exp(x)
setcs wfont=Arial
set wfont_size=18
setcs xfont='Noto Sans'
*set xfont_size=18

set xgridwidth=4
set xbrushwidth=1
set color0=white
*set color2=brown
set color2=rgbd:255/0/0
plot y vs x xlabel 'Labellisé X' ylabel 'Labellisé Y: ÜüÖöÄäÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜÜ' title 'Titré'
set color0=black
plot y vs x xlabel '我能吞下玻璃而不伤身体' ylabel 'Я могу есть стекло, оно мне не вредит' title ' أنا قادر على أكل الزجاج و هذا لا يؤلمني.'
* With Linux the next one requires: export LC_CTYPE ="de_DE.UTF-8"
*gnuplot test.gn y vs x xlabel 'Labellisé X' ylabel 'tüTÄtö Äü @µ€~' title 'ฉันกินกระจกได้ แต่มันไม่ทำให้ฉันเจ็บ '
set color0=Blue
set color1=Yellow
set color2=rgb:00/FF/00
set xgridwidth=1
set xbrushwidth=4
plot y vs x+0.001 xlabel 'Labellisé X' ylabel 'Labellisé Y' title 'Titré 私はガラスを食べられます。それは私を傷つけません' loglog
unset color1
set color0=MediumBlue
set color2=Magenta
plot y vs x+0.001 xlabel 'Labellisé X' title 'Titré' loglog
set color0=GreenYellow
set color2=rgbd:128/128/75
plot y vs x+0.001 xlabel 'Labellisé X' title 'Titré' loglog
set color0=black
set color2=pink
plot y vs x xlabel '래도 아프지 않아요' ylabel '私はガラスを食べられます' title ' أنا قادر على أكل الزجاج و هذا لا يؤلمني.'

* With Linux the next one requires: export LC_CTYPE ="de_DE.UTF-8"
*gnuplot test2.gn y vs x xlabel 'Labellisé X' ylabel 'tüTÄtö Äü @µ€~' title 'ฉันกินกระจกได้ แต่มันไม่ทำให้ฉันเจ็บ '

*hardcopy plot_5.ps y vs x xlabel 'Labellisé X' ylabel 'Labellisé Y' title 'Titré Äü @µ€~'
*shell Start /B plot_5.ps
*shell gv plot_5.ps &

echo 나는 유리를 먹을 수 있어요. 그래도 아프지 않아요
echo 私はガラスを食べられます。それは私を傷つけません
echo 我能吞下玻璃而不伤身体

*quit
.endc
